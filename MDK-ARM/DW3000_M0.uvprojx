# Keil uVision project DW3000_M0.uvprojx, settings and files
target DW3000_M0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: DW3000_M0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Src;../Src/platform;../Src/examples/shared_data;../Src/examples/examples_info;../Src/decadriver
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group paltform
    ../Src/platform/: deca_mutex.c deca_sleep.c deca_spi.c port.c
  group decadrive
    ../Src/decadriver/: deca_device.lib
  group examples
    ../Src/: config_options.c
    ../Src/examples/shared_data/: shared_functions.c
    ../Src/examples/examples_info/: example_info.c
    ../Src/examples/ex_05b_ds_twr_resp/: ds_twr_responder.c
    ../Src/examples/ex_05a_ds_twr_init/: ds_twr_initiator.c
    ../Src/examples/ex_02a_simple_rx/: simple_rx.c
    ../Src/examples/ex_01a_simple_tx/: simple_tx.c
software components: CMSIS:CORE 4.3.0
